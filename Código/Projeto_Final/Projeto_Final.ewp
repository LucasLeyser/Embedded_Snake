# IAR project Projeto_Final.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA1; TX_ENABLE_IAR_LIBRARY_SUPPORT
  ICCARM.CCIncludePath2: ..\..\ThreadX\common\inc; ..\..\ThreadX\ports\cortex_m4\iar; ..\..\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Projeto_Final.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Tiva.icf
  ILINK.IlinkAdditionalLibs: ..\..\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a; ..\..\TivaWare_C_Series-2.2.0.295\grlib\ewarm\Exe\grlib.a; ..\..\ThreadX\ports\cortex_m4\iar\example_build\Debug\Exe\tx.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    src/: cfaf128x128x16.c joystick.cpp lcd.cpp main.cpp pause_button.cpp snake_list.c startup_ewarm.c tx_initialize_low_level.s
